# IAR project YD_twrk60n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\lib\twrk60n512.iar\; ..\lib\twrk60n512.iar\bsp; ..\lib\twrk60n512.iar\psp; ..\lib\twrk60n512.iar\bsp\Generated_Code; ..\lib\twrk60n512.iar\rtcs; ..\lib\twrk60n512.iar\mfs; ..\lib\twrk60n512.iar\usb\host; ..\lib\twrk60n512.iar\shell; ..\lib\twrk60n512.iar\usb; ..; ..\Source\Source_MQX; E:\Freescale\Freescale MQX 3.8\shell\source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\lib\twrk60n512.iar\bsp; ..\lib\twrk60n512.iar\psp; ..\lib\twrk60n512.iar\bsp\Generated_Code; ..\lib\twrk60n512.iar; ..\lib\twrk60n512.iar\rtcs; ..\lib\twrk60n512.iar\mfs; ..\lib\twrk60n512.iar\usb\host; ..; ..\Source\Source_MQX
  OBJCOPY.OOCOutputFile: YD_twrk60n512.srec
  ILINK.IlinkOutputFile: twrk60n512.out
  ILINK.IlinkIcfFile: ..\lib\twrk60n512.iar\bsp\intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\..\lib\twrk60n512.iar\psp; ..\..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\..\lib\twrk60n512.iar
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk60n512.iar\bsp\intflash.icf
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
  group (top)
    E:/Freescale/Freescale MQX 3.8/shell/source/mfs/: sh_cd.c sh_di.c
  group MFS_Libs
    ../lib/twrk60n512.iar/mfs/: mfs_twrk60n512_d.a
  group MQX Libraries
    ../lib/twrk60n512.iar/bsp/: bsp_twrk60n512_130330_no_event_lpt.a bsp_twrk60n512_20130103.a bsp_twrk60n512_20130103_b.a bsp_twrk60n512_20130103_c.a bsp_twrk60n512_20130103_time.a bsp_twrk60n512_20130104.a bsp_twrk60n512_20130125.a bsp_twrk60n512_20130301.a bsp_twrk60n512_20130322_no_event.a bsp_twrk60n512_d_20121129.a bsp_twrk60n512_d_20121129_new.a wk_bsp_twrk60n512_d.a
    ../../../Freescale MQX 3.8/lib/twrk60n512.iar/bsp/: bsp_twrk60n512_d_20121014.a
    ../lib/twrk60n512.iar/psp/: psp_twrk60n512_d.a
  group RTCS_Libs
    ../lib/twrk60n512.iar/rtcs/: rtcs_twrk60n512_d.a rtcs_twrk60n512_d_20130102.a rtcs_twrk60n512_d_20130105.a
  group Shell_Libs
    ../lib/twrk60n512.iar/shell/: shell_twrk60n512_d.a shell_twrk60n512_d_20130102.a shell_twrk60n512_d_20130228.a shell_twrk60n512_d_20130317.a shell_twrk60n512_d_20130318.a shell_twrk60n512_d_20130319.a shell_twrk60n512_d_20130401.a
  group Source
    ../Source/: DataConvert.c DSPSPI.c LCDDriver.c LCDUart.c MenuView.c pin2.c System.C yada_prj.c
  group Source/mem
    ../Source/: mem_flash.c mem_ram.c
  group Source/Source_MQX
    ../Source/Source_MQX/: FTP_Task.c FTP_Task.h SD_task.c Shell_Task.c Shell_Task.h usb_classes.h USB_File.c USB_File.h USB_Task.c USB_Task.h
  group Source/TCPSocket
    ../Source/Source_MQX/: tcpip_socket_task.c
  group USB_Libs
    ../lib/twrk60n512.iar/usb/host/: usb_classes.c usb_hdk_twrk60n512_d.a
